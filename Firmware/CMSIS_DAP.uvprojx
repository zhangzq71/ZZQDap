# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target CMSIS-DAP-V1-F102 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F102C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP-V1-F102 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1 STM32F102C8
  c include: .;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: .\CMSIS_DAP-C8.sct
  group CMSIS-DAP
    ./: startup_stm32f10x_hd.s startup_stm32f10x_md.s system_stm32f10x.c CMSIS-DAP.c UserApp.c usb_config.c usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c DAP_config.h CMSIS_DAP-C8.sct CMSIS_DAP-CB.sct
  group Lib
    ./: USB_CM3.lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c
target CMSIS-DAP-V1-F103 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP-V1-F103 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V1
  c include: .;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
target CMSIS-DAP-V2-F102 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F102C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: CMSIS-DAP-V2-F102 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2 STM32F102C8
  c include: .;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: .\CMSIS_DAP-C8.sct
target CMSIS-DAP-V2-F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: CMSIS-DAP-V2-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_V2
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
target CMSIS-DAP-V3-F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: CMSIS-DAP-V3-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V20
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
target CMSIS-DAP-STLINKV21 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: CMSIS-DAP-STLINK21 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD STLINK_V21
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP-C8.sct
target STM32RF (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: CMSIS-DAP-RF +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD BOARD_STM32RF
  c include: .;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\CMSIS_DAP.sct
software components: CMSIS:CORE 5.0.2
